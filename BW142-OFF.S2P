!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5244A)
! VAR MeasDate=11/21/2012 5:53:46 PM
! VAR NAME=128935 2
! VAR FILENAME=128935 2.S2P
! VAR DATE=11/21/2012 5:53:46 PM
! VAR PHYS_PORTS=1,2
# Hz S MA R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 100 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -39.63 dB at 947.9 MHz (marker M1); lowest = -90.9 dB at 17.86 GHz (marker M2)
!   lowest |S11| = -1.3 dB at 28.78 GHz (marker M3), VSWR 12.92, Z = 5.19 + j29 ohm
!   |S11| at or under -10 dB: nowhere
!   |S22| runs from -1.3 to 0.0 dB; largest |S21 - S12| = 0.0048
!   S11 on the Smith chart (normalised r, x): 100 MHz: 0, -12; 898 MHz: 0.02, -1.29; 2.993 GHz: 0.03, -0.34; 17.06 GHz: 0.04, +0.24; 31.32 GHz: 0.07, +0.68; 40 GHz: 0.17, +1.17
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  0.0  -77.1  -58.8  0.0
! 349.4 MHz  0.0  -49.9  -48.7  0.0
! 898 MHz  -0.2  -40.7  -40.7  -0.2
! 947.9 MHz  -0.2  -39.6  -40.2  -0.2
! 2.993 GHz  -0.4  -42.9  -43.2  -0.5
! 6.783 GHz  -0.5  -50.1  -51.4  -0.5
! 13.42 GHz  -0.7  -54.3  -58.1  -0.7
! 15.21 GHz  -0.7  -56.1  -56.2  -0.7
! 16.21 GHz  -0.7  -61.1  -59.8  -0.7
! 17.06 GHz  -0.7  -66.3  -56.0  -0.7
! 17.86 GHz  -0.7  -90.9  -64.4  -0.7
! 18.6 GHz  -0.7  -61.6  -70.5  -0.7
! 19.05 GHz  -0.7  -70.3  -61.6  -0.7
! 20.05 GHz  -0.7  -58.1  -60.5  -0.7
! 21.15 GHz  -0.7  -64.2  -71.7  -0.7
! 23.64 GHz  -0.7  -64.1  -56.1  -0.7
! 26.73 GHz  -0.7  -59.8  -61.1  -0.7
! 28.78 GHz  -1.3  -57.9  -53.7  -0.8
! 31.32 GHz  -0.8  -53.4  -77.8  -0.8
! 33.37 GHz  -0.8  -52.8  -63.6  -0.9
! 34.21 GHz  -0.9  -57.8  -53.9  -0.9
! 40 GHz  -1.3  -48.0  -47.0  -1.2
